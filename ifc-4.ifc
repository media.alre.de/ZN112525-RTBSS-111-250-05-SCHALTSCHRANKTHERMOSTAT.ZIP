Properties of the parts of a building model (IFC4)

# File
Description: Schaltschrankthermostat, 0…60 °C, Schließer, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: ZN112525, Schaltschrankthermostat, 0…60 °C, Schließer
In: Raum
Description: Schaltschranktemperaturregler speziell zur Überwachung und Regelung der Temperatur in Schaltschränken, Getränke- oder Geldautomaten. Prüfzeichen UL und VDE. Das Gerät benötigt keine Versorgungsspannung.; Classification: EC004587 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: ZN112525; ModelLabel: RTBSS-111.250/05; GlobalTradeItemNumber: 4050528065193; ProductURL: https://alre.de/produkt_ZN112525
Pset_Specification - NominalLength: 0.064 m; NominalWidth: 0.046 m; NominalDepth: 0.037 m; NetWeight: 0.068
Pset_ALRE_ETIM_Properties - Montageart: sonstige; Ausführung: Thermostat; Ausführung der Schaltfunktion: Schließer (NO); Bemessungsspannung AC 50 Hz: 230; Bemessungsstrom In: 10; Einstellbereich Temperatur: 0; ETIM-Klasse: EC004587; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-ZN112525.pdf
